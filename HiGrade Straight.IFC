Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\highgrade\STRAIGHT.IFC
Time: 2026-05-01T10:03:10+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: STRAIGHT; GA: No; Number: STR - 02 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 11.07
PSet_Mass_Property - Area Measure: 0.9662131965393765; Mass Measure: 11.0656333499229476; Volume Measure: 0.0014186709422978

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: STRAIGHT; GA: No; Number: STR - 02 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 11.07
PSet_Mass_Property - Area Measure: 0.9662131965393765; Mass Measure: 11.0656333499229476; Volume Measure: 0.0014186709422978

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: STRAIGHT; GA: No; Number: STR - 02 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 11.07
PSet_Mass_Property - Area Measure: 0.9662131965393765; Mass Measure: 11.0656333499229476; Volume Measure: 0.0014186709422978

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (4)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | Author = RevCreatedBy | DESCRIPTION | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision | WEIGHT
GS2 | J.S | GS2 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.75
Part1^STRAIGHT |  | Part1^STRAIGHT |  |  |  |  |  | 8.81
GS2-1 | J.S | GS2 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.75
GS2-2 | J.S | GS2 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.75

# IfcElementAssembly, STRAIGHT
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: STRAIGHT; GA: No; Number: STR - 02 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 11.07
PSet_Mass_Property - Area Measure: 0.9662131965393765; Mass Measure: 11.0656333499229476; Volume Measure: 0.0014186709422978
