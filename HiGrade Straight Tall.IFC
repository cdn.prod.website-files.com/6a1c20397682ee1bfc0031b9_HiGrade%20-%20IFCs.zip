Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-ST01.IFC
Time: 2026-05-01T10:17:37+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-ST01; Fixing Method: Custom (Please Specify); GA: No; Number: STR - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 12.02
PSet_Mass_Property - Area Measure: 1.0457377290092986; Mass Measure: 12.0247735635818653; Volume Measure: 0.0015416376363566

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-ST01; Fixing Method: Custom (Please Specify); GA: No; Number: STR - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 12.02
PSet_Mass_Property - Area Measure: 1.0457377290092986; Mass Measure: 12.0247735635818653; Volume Measure: 0.0015416376363566

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-ST01; Fixing Method: Custom (Please Specify); GA: No; Number: STR - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 12.02
PSet_Mass_Property - Area Measure: 1.0457377290092986; Mass Measure: 12.0247735635818653; Volume Measure: 0.0015416376363566

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (3)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Author = RevCreatedBy | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision
Part1^KI-0001-ST01 | Part1^KI-0001-ST01 | 10.22
KI-0000-GS01 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01

# IfcElementAssembly, KI-0001-ST01
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-ST01; Fixing Method: Custom (Please Specify); GA: No; Number: STR - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: ST01; WEIGHT: 12.02
PSet_Mass_Property - Area Measure: 1.0457377290092986; Mass Measure: 12.0247735635818653; Volume Measure: 0.0015416376363566
