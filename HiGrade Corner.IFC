Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\highgrade\CORNER.IFC
Time: 2026-05-01T10:02:01+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: CORNER; GA: No; Number: C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05; WEIGHT: 9.98
PSet_Mass_Property - Area Measure: 0.8696244569704318; Mass Measure: 9.9808203751393165; Volume Measure: 0.0012795923557871

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: CORNER; GA: No; Number: C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05; WEIGHT: 9.98
PSet_Mass_Property - Area Measure: 0.8696244569704318; Mass Measure: 9.9808203751393165; Volume Measure: 0.0012795923557871

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: CORNER; GA: No; Number: C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05; WEIGHT: 9.98
PSet_Mass_Property - Area Measure: 0.8696244569704318; Mass Measure: 9.9808203751393165; Volume Measure: 0.0012795923557871

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (3)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | Author = RevCreatedBy | DESCRIPTION | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision | WEIGHT
GS2 | J.S | GS2 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.75
GS2-1 | J.S | GS2 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.75
Part1^CORNER |  | Part1^CORNER |  |  |  |  |  | 8.47

# IfcElementAssembly, CORNER
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: CORNER; GA: No; Number: C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05; WEIGHT: 9.98
PSet_Mass_Property - Area Measure: 0.8696244569704318; Mass Measure: 9.9808203751393165; Volume Measure: 0.0012795923557871
