Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\highgrade\CURVE.IFC
Time: 2026-05-01T10:02:27+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - DESCRIPTION: CURVE; WEIGHT: 8.21
PSet_Mass_Property - Area Measure: 0.7221467022020934; Mass Measure: 8.2106320180561596; Volume Measure: 0.0010526451305200

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - DESCRIPTION: CURVE; WEIGHT: 8.21
PSet_Mass_Property - Area Measure: 0.7221467022020934; Mass Measure: 8.2106320180561596; Volume Measure: 0.0010526451305200

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - DESCRIPTION: CURVE; WEIGHT: 8.21
PSet_Mass_Property - Area Measure: 0.7221467022020934; Mass Measure: 8.2106320180561596; Volume Measure: 0.0010526451305200

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (5)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
PLANTER WALL^CURVE | PLANTER WALL^CURVE | 5.47
BASE RETURN^CURVE | BASE RETURN^CURVE | 0.86
GS2 | GS2 | 0.75 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
TOP RETURN^CURVE | TOP RETURN^CURVE | 0.38
GS2-1 | GS2 | 0.75 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01

# IfcElementAssembly, CURVE
In: default BuildingStorey
SOLIDWORKS Custom Properties - DESCRIPTION: CURVE; WEIGHT: 8.21
PSet_Mass_Property - Area Measure: 0.7221467022020934; Mass Measure: 8.2106320180561596; Volume Measure: 0.0010526451305200
