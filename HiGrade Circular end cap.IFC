Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-C01.IFC
Time: 2026-05-01T10:22:28+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.33
PSet_Mass_Property - Area Measure: 1.6025627774203530; Mass Measure: 18.3260093846019778; Volume Measure: 0.0023494883826413

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.33
PSet_Mass_Property - Area Measure: 1.6025627774203530; Mass Measure: 18.3260093846019778; Volume Measure: 0.0023494883826413

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.33
PSet_Mass_Property - Area Measure: 1.6025627774203530; Mass Measure: 18.3260093846019778; Volume Measure: 0.0023494883826413

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (6)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
KI-0000-GS01 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
PLANTER BODY^KI-0001-C01 | PLANTER BODY^KI-0001-C01 | 13.13 | SOLIDWORKS Custom Properties - Material: MILD STEEL
BASE RETURN^KI-0001-C01 | BASE RETURN^KI-0001-C01 | 1.73 | SOLIDWORKS Custom Properties - Material: MILD STEEL
TOP RETURN^KI-0001-C01 | TOP RETURN^KI-0001-C01 | 0.76 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-GS01-2 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01

# IfcElementAssembly, KI-0001-C01
In: default BuildingStorey
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.33
PSet_Mass_Property - Area Measure: 1.6025627774203530; Mass Measure: 18.3260093846019778; Volume Measure: 0.0023494883826413
