Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-LD-ST01.IFC
Time: 2026-05-01T10:20:47+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-LD-ST01; GA: No; Number: L-STR-01 - 300-600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01; TAC NUMBER: STL01; WEIGHT: 13.14
PSet_Mass_Property - Area Measure: 1.1446461192056749; Mass Measure: 13.1383898041958584; Volume Measure: 0.0016844089492559

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-LD-ST01; GA: No; Number: L-STR-01 - 300-600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01; TAC NUMBER: STL01; WEIGHT: 13.14
PSet_Mass_Property - Area Measure: 1.1446461192056749; Mass Measure: 13.1383898041958584; Volume Measure: 0.0016844089492559

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-LD-ST01; GA: No; Number: L-STR-01 - 300-600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01; TAC NUMBER: STL01; WEIGHT: 13.14
PSet_Mass_Property - Area Measure: 1.1446461192056749; Mass Measure: 13.1383898041958584; Volume Measure: 0.0016844089492559

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (4)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
KI-0000-LD-GS01 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
Part4^KI-0001-LD-ST01 | Part4^KI-0001-LD-ST01 | 3.10 | SOLIDWORKS Custom Properties - Material: MILD STEEL
Part3^KI-0001-LD-ST01 | Part3^KI-0001-LD-ST01 | 7.93 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-LD-GS01-1 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01

# IfcElementAssembly, KI-0001-LD-ST01
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: KI-0001-LD-ST01; GA: No; Number: L-STR-01 - 300-600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01; TAC NUMBER: STL01; WEIGHT: 13.14
PSet_Mass_Property - Area Measure: 1.1446461192056749; Mass Measure: 13.1383898041958584; Volume Measure: 0.0016844089492559
