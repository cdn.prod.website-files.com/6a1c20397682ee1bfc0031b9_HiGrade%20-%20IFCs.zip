Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\highgrade\INV CURVE.IFC
Time: 2026-05-01T10:02:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - DESCRIPTION: INV CURVE; WEIGHT: 8.69
PSet_Mass_Property - Area Measure: 0.7644653788502047; Mass Measure: 8.6893840792694448; Volume Measure: 0.0011140235999063

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - DESCRIPTION: INV CURVE; WEIGHT: 8.69
PSet_Mass_Property - Area Measure: 0.7644653788502047; Mass Measure: 8.6893840792694448; Volume Measure: 0.0011140235999063

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - DESCRIPTION: INV CURVE; WEIGHT: 8.69
PSet_Mass_Property - Area Measure: 0.7644653788502047; Mass Measure: 8.6893840792694448; Volume Measure: 0.0011140235999063

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (5)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
BASE FLANGE^INV CURVE | BASE FLANGE^INV CURVE | 1.22
GS2 | GS2 | 0.75 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
MAIN SHEET^INV CURVE | MAIN SHEET^INV CURVE | 5.52
TOP RETURN^INV CURVE | TOP RETURN^INV CURVE | 0.44
GS2-1 | GS2 | 0.75 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01

# IfcElementAssembly, INV CURVE
In: default BuildingStorey
SOLIDWORKS Custom Properties - DESCRIPTION: INV CURVE; WEIGHT: 8.69
PSet_Mass_Property - Area Measure: 0.7644653788502047; Mass Measure: 8.6893840792694448; Volume Measure: 0.0011140235999063
