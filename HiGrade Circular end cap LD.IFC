Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-LD-C01.IFC
Time: 2026-05-01T10:21:25+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.53
PSet_Mass_Property - Area Measure: 1.6263948136997739; Mass Measure: 18.5341916408706844; Volume Measure: 0.0023761784154962

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.53
PSet_Mass_Property - Area Measure: 1.6263948136997739; Mass Measure: 18.5341916408706844; Volume Measure: 0.0023761784154962

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.53
PSet_Mass_Property - Area Measure: 1.6263948136997739; Mass Measure: 18.5341916408706844; Volume Measure: 0.0023761784154962

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (7)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Material
KI-0000-LD-GS01 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
TOP RETURN^KI-0001-LD-C01 | TOP RETURN^KI-0001-LD-C01 | 0.56 | MILD STEEL
Part3^KI-0001-LD-C01 | Part3^KI-0001-LD-C01 | 11.60 | MILD STEEL
BASE RETURN^KI-0001-LD-C01 | BASE RETURN^KI-0001-LD-C01 | 1.51 | MILD STEEL
PLANTER BODY^KI-0001-LD-C01 | PLANTER BODY^KI-0001-LD-C01 | 2.00 | MILD STEEL
KI-0000-LD-GS01-1 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
Part4^KI-0001-LD-C01 | Part4^KI-0001-LD-C01 | 0.76 | MILD STEEL

# IfcElementAssembly, KI-0001-LD-C01
In: default BuildingStorey
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-C01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 18.53
PSet_Mass_Property - Area Measure: 1.6263948136997739; Mass Measure: 18.5341916408706844; Volume Measure: 0.0023761784154962
