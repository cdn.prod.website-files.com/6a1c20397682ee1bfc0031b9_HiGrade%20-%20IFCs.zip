Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\highgrade\INV CORNER.IFC
Time: 2026-05-01T10:02:46+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: INV CORNER; GA: No; Number: INV - C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C01; WEIGHT: 10.59
PSet_Mass_Property - Area Measure: 0.9261920880246148; Mass Measure: 10.5944296916405651; Volume Measure: 0.0013582602168770

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: INV CORNER; GA: No; Number: INV - C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C01; WEIGHT: 10.59
PSet_Mass_Property - Area Measure: 0.9261920880246148; Mass Measure: 10.5944296916405651; Volume Measure: 0.0013582602168770

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: INV CORNER; GA: No; Number: INV - C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C01; WEIGHT: 10.59
PSet_Mass_Property - Area Measure: 0.9261920880246148; Mass Measure: 10.5944296916405651; Volume Measure: 0.0013582602168770

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (5)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
GS2 | GS2 | 0.75 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
TOP CORNER INFILL^INV CORNER | TOP CORNER INFILL^INV CORNER | 0.04
BASE INFILL^INV CORNER | BASE INFILL^INV CORNER | 0.66
GS2-1 | GS2 | 0.75 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
PLANTER WALL^INV CORNER | PLANTER WALL^INV CORNER | 8.38

# IfcElementAssembly, INV CORNER
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; DESCRIPTION: INV CORNER; GA: No; Number: INV - C - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C01; WEIGHT: 10.59
PSet_Mass_Property - Area Measure: 0.9261920880246148; Mass Measure: 10.5944296916405651; Volume Measure: 0.0013582602168770
